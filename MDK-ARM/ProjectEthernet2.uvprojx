# Keil uVision project ProjectEthernet2.uvprojx, settings and files
target ProjectEthernet2 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: ProjectEthernet2
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: --C99
  c include: ../Inc;  ../Middlewares/Third_Party/LwIP/src/include;  ../Middlewares/Third_Party/LwIP/system;  ../Drivers/STM32F4xx_HAL_Driver/Inc;  ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;  ../Middlewares/Third_Party/LwIP/src/include/lwip;  ../Middlewares/Third_Party/LwIP/src/include/lwip/apps;  ../Middlewares/Third_Party/LwIP/src/include/lwip/priv;  ../Middlewares/Third_Party/LwIP/src/include/netif;  ../Middlewares/Third_Party/LwIP/src/include/netif/ppp;  ../Middlewares/Third_Party/LwIP/src/include/netif/ppp/polarssl;  ../Middlewares/Third_Party/LwIP/src/include/posix;  ../Middlewares/Third_Party/LwIP/src/include/posix/sys;  ../Middlewares/Third_Party/LwIP/system/arch;  ../Drivers/CMSIS/Include;  ../Drivers/CMSIS/Device/ST/STM32F4xx/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_eth.c stm32f4xx_hal_cortex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_rcc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal.c stm32f4xx_hal_dma.c stm32f4xx_hal_adc.c stm32f4xx_hal_uart.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_dma_ex.c
  group Application/User
    ../Src/: ethernetif.c main.c stm32f4xx_hal_timebase_TIM.c lwip.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Middlewares/LwIP
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: ip4_addr.c dhcp.c icmp.c ip_frag.c autoip.c igmp.c ip4.c
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/: ipv6cp.c chap-new.c upap.c pppcrypt.c eap.c pppoe.c mppe.c demand.c ppp.c ipcp.c ecp.c lcp.c auth.c pppol2tp.c pppos.c multilink.c vj.c utils.c chap_ms.c magic.c chap-md5.c fsm.c ccp.c eui64.c
    ../Middlewares/Third_Party/LwIP/src/core/: tcp_in.c mem.c sys.c init.c tcp.c raw.c memp.c inet_chksum.c udp.c stats.c pbuf.c tcp_out.c netif.c def.c dns.c lwip_timers.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv6/: ip6_addr.c icmp6.c ip6.c ip6_frag.c dhcp6.c mld6.c inet6.c nd6.c ethip6.c
    ../Middlewares/Third_Party/LwIP/src/api/: pppapi.c sockets.c tcpip.c err.c netbuf.c netifapi.c api_lib.c api_msg.c netdb.c
    ../Middlewares/Third_Party/LwIP/src/netif/: etharp.c slipif.c
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/polarssl/: md5.c arc4.c md4.c des.c sha1.c
  group Drivers/CMSIS
    ../Drivers/CMSIS//Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
software components: CMSIS:CORE 4.1.0
